## base_external/Config.in
```kconfig
source "/home/gabry/Documents/aesd/assignment-4/base_external/package/aesd-assignments/Config.in"
```
